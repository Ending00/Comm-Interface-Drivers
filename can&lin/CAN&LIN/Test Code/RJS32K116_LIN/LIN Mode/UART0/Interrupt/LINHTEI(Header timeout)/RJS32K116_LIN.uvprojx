# Keil uVision project RJS32K116_LIN.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: RJS32K116_CAN_HSI24M +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\..\CMSIS;.\User;.\App\Inc;.\System\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./User/: main.c rjs32k116_it.c
  group CMSIS
    ../../../../../../CMSIS/: startup_rjs32k116.s
  group SYSTEM
    ./System/Src/: uart.c crg.c delay.c can.c
