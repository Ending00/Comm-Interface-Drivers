# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\user;..\core;..\system\delay;..\system\sys;..\system\usart;..\driver;..\bsp;..\app;..\app\OLED;..\app\ESP8266
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group app
    ../app/ESP8266/: apsta.c common.c wifiap.c wifista.c
    ../app/OLED/: oled.c
  group driver
    ../driver/: button_drv.c pwm_drv.c rgb_drv.c
  group pal
    ../driver/: pal_button.c pal_rgb.c
  group bsp
    ../bsp/: bsp_key.c bsp_pwm.c bsp_iic.c bsp_usart2.c bsp_led.c
  group malloc
    ../bsp/: malloc.c
  group stm32f103_fwlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group readme
    ../: README.TXT
